REQUIRED_DISTRO_FEATURES = "wpe-2.22"

